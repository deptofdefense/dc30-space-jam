options:
  parameters:
    category: Custom
    description: DVB-S2 Jamming Simulator
    generate_options: qt_gui
    id: dvbs2_tx_rx
    output_language: python
    title: DVB-S2 Jamming Simulation
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: EsN0_jam
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: Es_jam
  id: variable
  parameters:
    value: '1'
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: N0_jam
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Es/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: snr
  states: {}
- name: jammer_power_qtgui_range
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@5
    label: jammer power
    start: '0'
    step: '.1'
    stop: '50'
    value: '0'
    widget: slider
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: qtgui_freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: freq_offset
  states: {}
- name: qtgui_freq_offset_0
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@5
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: freq_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: signal_power_qtgui_range
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: signal power
    start: '0'
    step: '.1'
    stop: '5'
    value: '1'
    widget: slider
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/james/sat_jam_demo/output/no_jam.ts
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: Legitimate Input
    file: in_file
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    comment: Jammer Input
    file: /home/hacked.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: signal_power_qtgui_range
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: jammer_power_qtgui_range
    type: complex
  states: {}
- name: blocks_rotator_cc_foffset_sim
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '-2 * pi * (qtgui_freq_offset / samp_rate)'
  states: {}
- name: blocks_rotator_cc_foffset_sim_0
  id: blocks_rotator_cc
  parameters:
    comment: Simulate frequency offset
    phase_inc: '-2 * pi * (qtgui_freq_offset_0 / samp_rate)'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: debug
  id: parameter
  parameters:
    label: debugging level
    short_id: d
    type: intx
    value: '0'
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbheader_bb_0_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_interleaver_bb_0_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_modulator_bc_0_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C1_4
  states: {}
- name: dtv_dvbs2_physical_cc_0_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C1_4
  states: {}
- name: dvbs2rx_rx_hier_0
  id: dvbs2rx_rx_hier
  parameters:
    agc_gain: agc_gain
    agc_rate: agc_rate
    agc_ref: agc_ref
    debug: debug
    frame_size: frame_size
    gold_code: gold_code
    modcod: modcod
    pl_freq_est_period: pl_freq_est_period
    rolloff: rolloff
    rrc_delay: rrc_delay
    rrc_nfilts: rrc_nfilts
    sps: sps
    sym_rate: sym_rate
    sym_sync_damping: sym_sync_damping
    sym_sync_loop_bw: sym_sync_loop_bw
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    label: simulated carrier frequency offset in Hz
    type: eng_float
    value: '1000'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: path to input file containing an MPEG TS stream
    type: str
    value: /home/benign.ts
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps / 2)
    taps: firdes.root_raised_cosine(sps, samp_rate, sym_rate, rolloff, n_rrc_taps)
    type: ccf
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: int(sps / 2)
    taps: firdes.root_raised_cosine(sps, samp_rate, sym_rate, rolloff, n_rrc_taps)
    type: ccf
  states: {}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK1/4
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@4
    legend: 'False'
    name: '"PL Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: Before
    label2: After
    name: '"Frequency Correction"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: I
    label2: Q
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '10'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '1000000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Simulation
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    label5: Jammer
    num_tabs: '6'
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: phy-channel-in
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: jam-channel-in
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: phy-channel-in
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: jam-channel-in
  states: {}

connections:
- [blocks_add_xx_0, '0', dvbs2rx_rx_hier_0, '0']
- [blocks_file_source_0_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [blocks_file_source_0_0_0, '0', dtv_dvb_bbheader_bb_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_rotator_cc_foffset_sim, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_rotator_cc_foffset_sim_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_1_0_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbheader_bb_0_0, '0', dtv_dvb_bbscrambler_bb_0_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0_0, '0', dtv_dvb_bch_bb_0_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_bch_bb_0_0, '0', dtv_dvb_ldpc_bb_0_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvb_ldpc_bb_0_0, '0', dtv_dvbs2_interleaver_bb_0_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_interleaver_bb_0_0, '0', dtv_dvbs2_modulator_bc_0_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', dtv_dvbs2_physical_cc_0, '0']
- [dtv_dvbs2_modulator_bc_0_0, '0', dtv_dvbs2_physical_cc_0_0, '0']
- [dtv_dvbs2_physical_cc_0, '0', interp_fir_filter_xxx_0, '0']
- [dtv_dvbs2_physical_cc_0_0, '0', interp_fir_filter_xxx_0_0, '0']
- [dvbs2rx_rx_hier_0, '0', blocks_file_sink_0, '0']
- [dvbs2rx_rx_hier_0, '1', qtgui_const_sink_x_1_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_const_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_time_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '3', qtgui_freq_sink_x_0, '1']
- [dvbs2rx_rx_hier_0, '4', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_throttle_0_0, '0']
- [virtual_source_1_0_0, '0', blocks_rotator_cc_foffset_sim, '0']
- [virtual_source_1_0_0_0, '0', blocks_rotator_cc_foffset_sim_0, '0']

metadata:
  file_format: 1
